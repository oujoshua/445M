# Keil uVision project board2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: board2
  c flags: Optim=3
  c include: ..;..\..\;..\..\..\;..\..\driverlib;..\..\inc;.\;..\..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: board2_main.c
  group OS
    ../../src/: edisk.c eFile.c MAC.c OS.c OS_Buttons.c OS_Critical.c OS_DataStructures.c OS_Ethernet.c OS_Memory.c OS_Threads.c OS_Time.c Output.c Retarget.c rit128x96x4.c shell.c UART.c osasm.s Startup.s
  group drivers
    ../../src/: OS_Ethernet.c commands.h ADC.c IR.c PingMeasure.c
  group Library
    ../../driverlib/rvmdk/: driverlib.lib
