# Keil uVision project board1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: board1
  c flags: Optim=3
  c include: ..;..\..\;..\..\..\;..\..\driverlib;..\..\inc;.\;..\..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: board1_main.c
  group Library
    ../../driverlib/rvmdk/: driverlib.lib
  group OS
    ../../src/: OS.c OS_Buttons.c OS_Critical.c OS_DataStructures.c OS_Ethernet.c OS_Memory.c OS_Threads.c OS_Time.c Output.c rit128x96x4.c shell.c sqrt.c UART.c edisk.c eFile.c osasm.s Startup.s MAC.c Retarget.c
  group drivers
    ../../src/: FlexibleTimer0APWM.c ADC.c PWM.c PingMeasure.c IR.c commands.c fuzzy.c bump.c
